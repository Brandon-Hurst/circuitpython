## ports/zephyr-cp/boards/apard32690_max32690_m4.conf
```kconfig
# For debugging Zephyr integrations
CONFIG_DISK_LOG_LEVEL_DBG=y
CONFIG_USBD_LOG_LEVEL_DBG=y
```
